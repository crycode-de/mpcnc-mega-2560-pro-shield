# Repository crycode-de/mpcnc-mega-2560-pro-shield

File README.md:

# MPCNC Mega 2560 Pro Shield

A CNC Shield for the [Mostly Printed CNC](https://www.v1engineering.com/specifications/) (MPCNC) by V1 Engineering intended to be used with Estlcam.

## License

**Creative Commons CC-BY-SA-NC 4.0 License**

Created and Copyright 2020-2023 by
* Peter Müller <peter@crycode.de>
* Günter Brauer <gbzzr1100@gmail.de>

Parts based on [MPCNC Nano Estlcam Shield](https://github.com/tnn85/MPCNC-Nano-Estlcam-Shield) by Till Nenz.

## EAGLE design MPCNC Mega 2560 Pro.brd

Parts:
AIN6, AIN7, AIN8: 22-27-2031-03; 6410-03
IC1: MEGA2560-PRO
J5: 22-27-2021-02; 6410-02
LSP1, LSP2, LSP3, LSP4, LSP5, LSP6, LSP7, LSP8, LSP9, LSP10, LSP11: LSP09
SV1: ML26
SV2: ML10

Connections:
3V3: IC1.3V3@1 (3V3), IC1.3V3@2 (3V3)
!RESET: IC1.RST (!RESET), J5.1
+5V: AIN6.1, AIN7.1, AIN8.1, IC1.5V@1 (5V), IC1.5V@2 (5V), SV1.1, SV1.2, SV2.9; also elsewhere on the board
+12V: SV1.25, SV1.26; also elsewhere on the board
A6: IC1.A6, LSP8.MP
A7: IC1.A7, LSP9.MP
ADC_1: IC1.A8, SV2.1
ADC_2: IC1.A9, SV2.2
ADC_3: IC1.A10, SV2.3
ADC_4: IC1.A11, SV2.4
ADC_5: IC1.A12, SV2.5
ADC_6: AIN6.2, IC1.A13, SV2.6
ADC_7: AIN7.2, IC1.A14, SV2.7
ADC_8: AIN8.2, IC1.A15, SV2.8
D2: IC1.D2, LSP1.MP
D3: IC1.D3, LSP2.MP
D4: IC1.D4, LSP3.MP
D5: IC1.D5, LSP4.MP
D6: IC1.D6, LSP5.MP
D7: IC1.D7, LSP6.MP
D38: IC1.D38, LSP7.MP
DIR_X: IC1.A0; also elsewhere on the board
DIR_Y: IC1.A1; also elsewhere on the board
DIR_Z: IC1.A2; also elsewhere on the board
ENCODER_A: IC1.D22, SV1.3
ENCODER_B: IC1.D23, SV1.4
GND: AIN6.3, AIN7.3, AIN8.3, IC1.GND@1 (GND), IC1.GND@2 (GND), J5.2, SV1.23, SV1.24, SV2.10; also elsewhere on the board
IN_1: IC1.D53; also elsewhere on the board
IN_2: IC1.D52; also elsewhere on the board
IN_3: IC1.D51; also elsewhere on the board
IN_4: IC1.D50; also elsewhere on the board
IN_5: IC1.D10; also elsewhere on the board
IN_6: IC1.D11; also elsewhere on the board
IN_7: IC1.D12; also elsewhere on the board
IN_8: IC1.D13; also elsewhere on the board
IN_9: IC1.D49; also elsewhere on the board
IN_10: IC1.D48; also elsewhere on the board
IN_11: IC1.D47; also elsewhere on the board
IN_12: IC1.D46; also elsewhere on the board
IN_13: IC1.D45; also elsewhere on the board
IN_14: IC1.D44; also elsewhere on the board
IN_15: IC1.D43; also elsewhere on the board
IN_16: IC1.D42; also elsewhere on the board
LED_EXT_X: SV1.20; also elsewhere on the board
LED_EXT_Y: SV1.21; also elsewhere on the board
LED_EXT_Z: SV1.22; also elsewhere on the board
LED_X: IC1.D39; also elsewhere on the board
LED_Y: IC1.D40; also elsewhere on the board
LED_Z: IC1.D41; also elsewhere on the board
OK: IC1.D30, SV1.11
OUT_1: IC1.D14; also elsewhere on the board
OUT_2: IC1.D15; also elsewhere on the board
OUT_3: IC1.D16; also elsewhere on the board
OUT_4: IC1.D17; also elsewhere on the board
OUT_5: IC1.D18; also elsewhere on the board
OUT_6: IC1.D19; also elsewhere on the board
OUT_7: IC1.D20; also elsewhere on the board
OUT_8: IC1.D21; also elsewhere on the board
PROGRAM_START: IC1.D34, SV1.15
PROGRAM_STOP: IC1.D33, SV1.14
RX: IC1.RX, LSP10.MP
SELECT_X: IC1.D37, SV1.18
SELECT_Y: IC1.D36, SV1.17
SELECT_Z: IC1.D35, SV1.16
SPEED_1: IC1.D24, SV1.5
SPEED_2: IC1.D25, SV1.6
SPEED_3: IC1.D26, SV1.7
SPEED_4: IC1.D27, SV1.8
SPEED_5: IC1.D28, SV1.9
SPEED_6: IC1.D29, SV1.10
SPINDLE_ON_OFF: IC1.D8; also elsewhere on the board
SPINDLE_SPEED_PWM: IC1.D9; also elsewhere on the board
SPINDLE_START: IC1.D32, SV1.13
SPINDLE_STOP: IC1.D31, SV1.12
STEP_X: IC1.A3; also elsewhere on the board
STEP_Y: IC1.A4; also elsewhere on the board
STEP_Z: IC1.A5; also elsewhere on the board
TX: IC1.TX, LSP11.MP
VIN: IC1.VIN@1 (VIN), IC1.VIN@2 (VIN)

Notes on the sheet:
Manual Control Unit
Analog In
Mega 2560 Pro Board
Solder pads for currently unused pins
Sheet:
External Reset

Parts:
C7: 22 µF / 50 V Low ESR; E2-5
D1, D2: 1N5822; C4111-15
FAN: 22-27-2031-03; 6410-03
J4: Stepper Enable; 6410-02
JP10: JP2E; JP2
LED1, LED2, LED3: 2mA, bl; CHIPLED_1206
R1: 22k; R1206
R7, R50: 4k7; R1206
R8: 1k2; R1206
T1: BC817-25-NPN-SOT23-BEC; SOT23-BEC
U1: TSR2-24120; TSR2
U2: TSR2-2450; TSR2
X1: MSTBV2
X2, X3: 22-27-2031-03; 6410-03

Connections:
+5V: LED3.A, U2.3 (VO), X2.1, X3.1; also elsewhere on the board
+12V: FAN.2, LED2.A, U1.3 (VO), X2.2, X3.2; also elsewhere on the board
GND: C7.-, FAN.1, J4.2, JP10.1, R1.1, R7.1, R8.1, T1.E, U1.2 (GND), U2.2 (GND), X1.2, X2.3, X3.3; also elsewhere on the board
unnamed: LED1.C, R1.2
unnamed: D1.A, D2.A, X1.1
unnamed: LED2.C, R7.2
unnamed: LED3.C, R8.2
unnamed: R50.2, T1.B
unnamed: JP10.3, T1.C
OUT_8: R50.1; also elsewhere on the board
STEPPER_ENABLE: J4.1, JP10.2; also elsewhere on the board
VMOT: C7.+, D1.C, D2.C, LED1.A, U1.1 (VI), U2.1 (VI); also elsewhere on the board

Notes on the sheet:
V In
+5V / +12V Step Down
Voltage Status LEDs
Stepper Driver Enable
+5V / +12V / GND Connectors
Fan Connector
Sheet:

Parts:
C1, C2, C3, C4, C5: 100 µF; E2,5-7
J1, J2, J3: 22-27-2031-03; 6410-03
JP1, JP2, JP3, JP4, JP5: JP1Q; JP1
MS-X1, MS-X2: JP3Q
MS-Y1, MS-Y2: JP3Q
MS-Z: JP3Q
S.DRIVER-X1, S.DRIVER-X2, S.DRIVER-Y1, S.DRIVER-Y2, S.DRIVER-Z: STEPPER-DRIVER
STEPPER-X1.1, STEPPER-X1.2, STEPPER-X2.1, STEPPER-X2.2: PINHEAD-4
STEPPER-Y1.1, STEPPER-Y1.2, STEPPER-Y2.1, STEPPER-Y2.2: PINHEAD-4
STEPPER-Z.1, STEPPER-Z.2: PINHEAD-4

Connections:
+5V: JP1.1, JP2.1, JP3.1, JP4.1, JP5.1, MS-X1.1, MS-X1.3, MS-X1.5, MS-X2.1, MS-X2.3, MS-X2.5, MS-Y1.1, MS-Y1.3, MS-Y1.5, MS-Y2.1, MS-Y2.3, MS-Y2.5, MS-Z.1, MS-Z.3, MS-Z.5, S.DRIVER-X1.RESET (!RESET), S.DRIVER-X1.SLEEP (!SLEEP), S.DRIVER-X2.RESET (!RESET), S.DRIVER-X2.SLEEP (!SLEEP), S.DRIVER-Y1.RESET (!RESET), S.DRIVER-Y1.SLEEP (!SLEEP), S.DRIVER-Y2.RESET (!RESET), S.DRIVER-Y2.SLEEP (!SLEEP), S.DRIVER-Z.RESET (!RESET), S.DRIVER-Z.SLEEP (!SLEEP); also elsewhere on the board
DIR_X: J1.1, S.DRIVER-X1.DIR, S.DRIVER-X2.DIR; also elsewhere on the board
DIR_Y: J2.1, S.DRIVER-Y1.DIR, S.DRIVER-Y2.DIR; also elsewhere on the board
DIR_Z: J3.1, S.DRIVER-Z.DIR; also elsewhere on the board
GND: C1.-, C2.-, C3.-, C4.-, C5.-, J1.3, J2.3, J3.3, S.DRIVER-X1.GND@1 (GND), S.DRIVER-X1.GND@2 (GND), S.DRIVER-X2.GND@1 (GND), S.DRIVER-X2.GND@2 (GND), S.DRIVER-Y1.GND@1 (GND), S.DRIVER-Y1.GND@2 (GND), S.DRIVER-Y2.GND@1 (GND), S.DRIVER-Y2.GND@2 (GND), S.DRIVER-Z.GND@1 (GND), S.DRIVER-Z.GND@2 (GND); also elsewhere on the board
unnamed: MS-X1.6, S.DRIVER-X1.M0
unnamed: MS-X1.4, S.DRIVER-X1.M1
unnamed: MS-X1.2, S.DRIVER-X1.M2
unnamed: S.DRIVER-X1.A1, STEPPER-X1.2.3
unnamed: S.DRIVER-X1.A2, STEPPER-X1.1.1
unnamed: S.DRIVER-X1.B1, STEPPER-X1.1.3
unnamed: S.DRIVER-X1.B2, STEPPER-X1.2.1
unnamed: STEPPER-X1.1.4, STEPPER-X1.2.2
unnamed: STEPPER-X1.1.2, STEPPER-X1.2.4
unnamed: MS-X2.4, S.DRIVER-X2.M1
unnamed: MS-X2.6, S.DRIVER-X2.M0
unnamed: MS-X2.2, S.DRIVER-X2.M2
unnamed: S.DRIVER-X2.A1, STEPPER-X2.2.3
unnamed: S.DRIVER-X2.A2, STEPPER-X2.1.1
unnamed: S.DRIVER-X2.B1, STEPPER-X2.1.3
unnamed: S.DRIVER-X2.B2, STEPPER-X2.2.1
unnamed: STEPPER-X2.1.4, STEPPER-X2.2.2
unnamed: STEPPER-X2.1.2, STEPPER-X2.2.4
unnamed: JP1.2, S.DRIVER-X1.FAULT (!FAULT)
unnamed: JP2.2, S.DRIVER-X2.FAULT (!FAULT)
unnamed: MS-Y1.4, S.DRIVER-Y1.M1
unnamed: MS-Y1.6, S.DRIVER-Y1.M0
unnamed: MS-Y1.2, S.DRIVER-Y1.M2
unnamed: S.DRIVER-Y1.A1, STEPPER-Y1.2.3
unnamed: S.DRIVER-Y1.A2, STEPPER-Y1.1.1
unnamed: S.DRIVER-Y1.B1, STEPPER-Y1.1.3
unnamed: S.DRIVER-Y1.B2, STEPPER-Y1.2.1
unnamed: STEPPER-Y1.1.4, STEPPER-Y1.2.2
unnamed: STEPPER-Y1.1.2, STEPPER-Y1.2.4
unnamed: MS-Y2.4, S.DRIVER-Y2.M1
unnamed: MS-Y2.6, S.DRIVER-Y2.M0
unnamed: MS-Y2.2, S.DRIVER-Y2.M2
unnamed: S.DRIVER-Y2.A1, STEPPER-Y2.2.3
unnamed: S.DRIVER-Y2.A2, STEPPER-Y2.1.1
unnamed: S.DRIVER-Y2.B1, STEPPER-Y2.1.3
unnamed: S.DRIVER-Y2.B2, STEPPER-Y2.2.1
unnamed: STEPPER-Y2.1.4, STEPPER-Y2.2.2
unnamed: STEPPER-Y2.1.2, STEPPER-Y2.2.4
unnamed: JP3.2, S.DRIVER-Y1.FAULT (!FAULT)
unnamed: JP4.2, S.DRIVER-Y2.FAULT (!FAULT)
unnamed: MS-Z.4, S.DRIVER-Z.M1
unnamed: MS-Z.6, S.DRIVER-Z.M0
unnamed: MS-Z.2, S.DRIVER-Z.M2
unnamed: S.DRIVER-Z.A1, STEPPER-Z.2.3
unnamed: S.DRIVER-Z.A2, STEPPER-Z.1.1
unnamed: S.DRIVER-Z.B1, STEPPER-Z.1.3
unnamed: S.DRIVER-Z.B2, STEPPER-Z.2.1
unnamed: STEPPER-Z.1.4, STEPPER-Z.2.2
unnamed: STEPPER-Z.1.2, STEPPER-Z.2.4
unnamed: JP5.2, S.DRIVER-Z.FAULT (!FAULT)
STEPPER_ENABLE: S.DRIVER-X1.ENABLE (!ENABLE), S.DRIVER-X2.ENABLE (!ENABLE), S.DRIVER-Y1.ENABLE (!ENABLE), S.DRIVER-Y2.ENABLE (!ENABLE), S.DRIVER-Z.ENABLE (!ENABLE); also elsewhere on the board
STEP_X: J1.2, S.DRIVER-X1.STEP, S.DRIVER-X2.STEP; also elsewhere on the board
STEP_Y: J2.2, S.DRIVER-Y1.STEP, S.DRIVER-Y2.STEP; also elsewhere on the board
STEP_Z: J3.2, S.DRIVER-Z.STEP; also elsewhere on the board
VMOT: C1.+, C2.+, C3.+, C4.+, C5.+, S.DRIVER-X1.VMOT, S.DRIVER-X2.VMOT, S.DRIVER-Y1.VMOT, S.DRIVER-Y2.VMOT, S.DRIVER-Z.VMOT; also elsewhere on the board

Notes on the sheet:
Stepper Driver X
Stepper Driver Y
Stepper Driver Z
External Stepper Driver Connectors
Sheet:

Parts:
C8: 100 µF; E2,5-7
IC2, IC3: ULN2003AD; SO16
IC4: SFH6156; SFH
IC5: LM358D; SO08
J9: Out Spindle; 6410-03
J11: VFD On/Off; 6410-02
J12: VFD 0-10V; 6410-02
JP6: JP2E; JP2
JP7: PWM; JP1
JP8: Analog; JP1
JP9: 5V / 10V; JP1
LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12: 2mA, bl; CHIPLED_0805
OUT1: Out 1; 6410-03
OUT2: Out 2; 6410-03
OUT3: Out 3; 6410-03
OUT4: Out 4; 6410-03
OUT5: Out 5; 6410-03
OUT6: Out 6; 6410-03
OUT7: Out 7; 6410-03
OUT8: Out 8; 6410-03
R2: 220; R1206
R3, R5: 10k; R1206
R4: 5k; RTRIM64W
R6, R9, R10, R11, R12, R13, R14, R15, R16, R17: 1k2; R1206

Connections:
+5V: JP6.3; also elsewhere on the board
+12V: IC5.8 (V+), JP6.1; also elsewhere on the board
GND: IC2.8 (GND), IC3.8 (GND), IC4.2 (K), IC5.4 (V-), J9.3, J12.2, JP8.1, LED4.C, LED5.C, LED6.C, LED7.C, LED8.C, LED9.C, LED10.C, LED11.C, LED12.C, OUT1.3, OUT2.3, OUT3.3, OUT4.3, OUT5.3, OUT6.3, OUT7.3, OUT8.3, R5.2; also elsewhere on the board
LED_EXT_X: IC2.16 (O1); also elsewhere on the board
LED_EXT_Y: IC2.15 (O2); also elsewhere on the board
LED_EXT_Z: IC2.14 (O3); also elsewhere on the board
LED_X: IC2.1 (I1); also elsewhere on the board
LED_Y: IC2.2 (I2); also elsewhere on the board
LED_Z: IC2.3 (I3); also elsewhere on the board
unnamed: IC4.1 (A), R2.1
unnamed: IC4.4 (C), J11.1
unnamed: IC4.3 (E), J11.2
unnamed: IC5.2 (-IN), JP9.2, R4.2 (S)
unnamed: R3.2, R4.3 (E)
unnamed: IC5.1 (OUT), J12.1, JP9.1, R3.1
unnamed: R4.1 (A), R5.1
unnamed: C8.-, JP8.2
unnamed: C8.+, IC5.3 (+IN), JP7.1, R6.1
unnamed: LED5.A, R10.2
unnamed: LED4.A, R9.2
unnamed: LED6.A, R11.2
unnamed: LED7.A, R12.2
unnamed: LED8.A, R13.2
unnamed: LED9.A, R14.2
unnamed: LED10.A, R15.2
unnamed: LED11.A, R16.2
unnamed: LED12.A, R17.2
OUT_1: IC3.4 (I4), R9.1; also elsewhere on the board
OUT_2: IC3.3 (I3), R10.1; also elsewhere on the board
OUT_3: IC3.2 (I2), R11.1; also elsewhere on the board
OUT_4: IC3.1 (I1), R12.1; also elsewhere on the board
OUT_5: IC2.7 (I7), R13.1; also elsewhere on the board
OUT_6: IC2.6 (I6), R14.1; also elsewhere on the board
OUT_7: IC2.5 (I5), R15.1; also elsewhere on the board
OUT_8: IC2.4 (I4), R16.1; also elsewhere on the board
OUT_COM: IC2.9 (CD+), IC3.9 (CD+), J9.1, JP6.2, OUT1.1, OUT2.1, OUT3.1, OUT4.1, OUT5.1, OUT6.1, OUT7.1, OUT8.1
OUT_EXT_1: IC3.13 (O4), OUT1.2
OUT_EXT_2: IC3.14 (O3), OUT2.2
OUT_EXT_3: IC3.15 (O2), OUT3.2
OUT_EXT_4: IC3.16 (O1), OUT4.2
OUT_EXT_5: IC2.10 (O7), OUT5.2
OUT_EXT_6: IC2.11 (O6), OUT6.2
OUT_EXT_7: IC2.12 (O5), OUT7.2
OUT_EXT_8: IC2.13 (O4), OUT8.2
OUT_EXT_SPINDLE: IC3.12 (O5), J9.2
SPINDLE_ON_OFF: IC3.5 (I5), R2.2, R17.1; also elsewhere on the board
SPINDLE_SPEED_PWM: JP7.2, R6.2; also elsewhere on the board

Notes on the sheet:
* VFD = Variable Frequency Drive
Spindle VFD On/Off
Output Voltage Select
Spindle On LED
Spindle On/Off Output
Spindle VFD Speed Control (0-10V / 0-5V)
Output Connectors
Output Status LEDs
Output Drivers
Sheet:

Parts:
IC6, IC7, IC8, IC9, IC10, IC11, IC12, IC13, IC14, IC15, IC16, IC17, IC18, IC19, IC20, IC21: SFH6156; SFH
LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28: 2mA, bl; CHIPLED_0805
R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33: 220; R1206
R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49: 1k2; R1206

Connections:
+5V: LED13.A, LED14.A, LED15.A, LED16.A, LED17.A, LED18.A, LED19.A, LED20.A, LED21.A, LED22.A, LED23.A, LED24.A, LED25.A, LED26.A, LED27.A, LED28.A, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2; also elsewhere on the board
GND: IC6.3 (E), IC7.3 (E), IC8.3 (E), IC9.3 (E), IC10.3 (E), IC11.3 (E), IC12.3 (E), IC13.3 (E), IC14.3 (E), IC15.3 (E), IC16.3 (E), IC17.3 (E), IC18.3 (E), IC19.3 (E), IC20.3 (E), IC21.3 (E); also elsewhere on the board
IN_1: IC6.4 (C); also elsewhere on the board
IN_2: IC7.4 (C); also elsewhere on the board
IN_3: IC8.4 (C); also elsewhere on the board
IN_4: IC9.4 (C); also elsewhere on the board
IN_5: IC10.4 (C); also elsewhere on the board
IN_6: IC11.4 (C); also elsewhere on the board
IN_7: IC12.4 (C); also elsewhere on the board
IN_8: IC13.4 (C); also elsewhere on the board
IN_9: IC14.4 (C); also elsewhere on the board
IN_10: IC15.4 (C); also elsewhere on the board
IN_11: IC16.4 (C); also elsewhere on the board
IN_12: IC17.4 (C); also elsewhere on the board
IN_13: IC18.4 (C); also elsewhere on the board
IN_14: IC19.4 (C); also elsewhere on the board
IN_15: IC20.4 (C); also elsewhere on the board
IN_16: IC21.4 (C); also elsewhere on the board
IN_EXT_1: IC6.2 (K), R34.2; also elsewhere on the board
IN_EXT_2: IC7.2 (K), R35.2; also elsewhere on the board
IN_EXT_3: IC8.2 (K), R36.2; also elsewhere on the board
IN_EXT_4: IC9.2 (K), R37.2; also elsewhere on the board
IN_EXT_5: IC10.2 (K), R38.2; also elsewhere on the board
IN_EXT_6: IC11.2 (K), R39.2; also elsewhere on the board
IN_EXT_7: IC12.2 (K), R40.2; also elsewhere on the board
IN_EXT_8: IC13.2 (K), R41.2; also elsewhere on the board
IN_EXT_9: IC14.2 (K), R42.2; also elsewhere on the board
IN_EXT_10: IC15.2 (K), R43.2; also elsewhere on the board
IN_EXT_11: IC16.2 (K), R44.2; also elsewhere on the board
IN_EXT_12: IC17.2 (K), R45.2; also elsewhere on the board
IN_EXT_13: IC18.2 (K), R46.2; also elsewhere on the board
IN_EXT_14: IC19.2 (K), R47.2; also elsewhere on the board
IN_EXT_15: IC20.2 (K), R48.2; also elsewhere on the board
IN_EXT_16: IC21.2 (K), R49.2; also elsewhere on the board
unnamed: LED14.C, R35.1
unnamed: LED13.C, R34.1
unnamed: LED15.C, R36.1
unnamed: LED16.C, R37.1
unnamed: LED17.C, R38.1
unnamed: LED18.C, R39.1
unnamed: LED19.C, R40.1
unnamed: LED20.C, R41.1
unnamed: LED21.C, R42.1
unnamed: LED22.C, R43.1
unnamed: IC6.1 (A), R18.1
unnamed: IC7.1 (A), R19.1
unnamed: IC8.1 (A), R20.1
unnamed: IC9.1 (A), R21.1
unnamed: IC10.1 (A), R22.1
unnamed: IC11.1 (A), R23.1
unnamed: IC12.1 (A), R24.1
unnamed: IC13.1 (A), R25.1
unnamed: IC14.1 (A), R26.1
unnamed: IC15.1 (A), R27.1
unnamed: IC16.1 (A), R28.1
unnamed: IC17.1 (A), R29.1
unnamed: IC18.1 (A), R30.1
unnamed: IC19.1 (A), R31.1
unnamed: IC20.1 (A), R32.1
unnamed: IC21.1 (A), R33.1
unnamed: LED23.C, R44.1
unnamed: LED24.C, R45.1
unnamed: LED25.C, R46.1
unnamed: LED26.C, R47.1
unnamed: LED27.C, R48.1
unnamed: LED28.C, R49.1

Notes on the sheet:
Digital Inputs (via Optocouplers)
Digital Input Status LEDs
Sheet:

Parts:
IN1, IN2, IN3, IN4, IN5, IN6, IN7, IN8, IN9, IN10, IN11, IN12, IN13, IN14, IN15, IN16: 22-27-2031-03; 6410-03

Connections:
+5V: IN1.1, IN2.1, IN3.1, IN4.1, IN5.1, IN6.1, IN7.1, IN8.1, IN9.1, IN10.1, IN11.1, IN12.1, IN13.1, IN14.1, IN15.1, IN16.1; also elsewhere on the board
GND: IN1.3, IN2.3, IN3.3, IN4.3, IN5.3, IN6.3, IN7.3, IN8.3, IN9.3, IN10.3, IN11.3, IN12.3, IN13.3, IN14.3, IN15.3, IN16.3; also elsewhere on the board
IN_EXT_1: IN1.2; also elsewhere on the board
IN_EXT_2: IN2.2; also elsewhere on the board
IN_EXT_3: IN3.2; also elsewhere on the board
IN_EXT_4: IN4.2; also elsewhere on the board
IN_EXT_5: IN5.2; also elsewhere on the board
IN_EXT_6: IN6.2; also elsewhere on the board
IN_EXT_7: IN7.2; also elsewhere on the board
IN_EXT_8: IN8.2; also elsewhere on the board
IN_EXT_9: IN9.2; also elsewhere on the board
IN_EXT_10: IN10.2; also elsewhere on the board
IN_EXT_11: IN11.2; also elsewhere on the board
IN_EXT_12: IN12.2; also elsewhere on the board
IN_EXT_13: IN13.2; also elsewhere on the board
IN_EXT_14: IN14.2; also elsewhere on the board
IN_EXT_15: IN15.2; also elsewhere on the board
IN_EXT_16: IN16.2; also elsewhere on the board

Notes on the sheet:
Digital In Connectors
Sheet:

Board: 2 copper layers, 160.0 x 100.0 mm, 194 parts (24 on the bottom side), 213 nets.

Other parts of the board:
U$1: 30MM

## Commit log

2020-01-10 Added readme and license, Added license information in circuit
2020-01-13 Renamed images
2020-01-17 Added reset connector, Fixed multiline information in circuit
2020-02-04 Vias are now covered with solder mask
2020-04-26 Switched to low current LEDs
2020-04-29 Fixed resistor value
2020-06-04 Added v1.2 rev 3 circuit pdf
2020-06-04 Added v1.2 rev 3 layout pdf
2023-12-01 V1.2 Rev. 4, Fixed issue #1
    Pin 2 and 3 of IC5 were swapped
    Thanks to @Gerssi for reporting!

Notices in the files:
MPCNC Mega 2560 Pro.brd:
CC BY-NC-SA 4.0
